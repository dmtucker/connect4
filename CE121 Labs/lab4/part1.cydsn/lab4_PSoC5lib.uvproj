# Keil uVision project lab4_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: lab4_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h LCD.c LCD.h LCD_PM.c Controller.c Controller.h Motor_aliases.h Motor.c Motor.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h PWM.c PWM.h PWM_PM.c ADC.c ADC.h ADC_PM.c ADC_INT.c Clock.c Clock.h ADC_theACLK.c ADC_theACLK.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_AMux.c ADC_AMux.h Accelerator_aliases.h Accelerator.c Accelerator.h Transmission_aliases.h Transmission.c Transmission.h ISR.c ISR.h Brake_aliases.h Brake.c Brake.h Taillight_aliases.h Taillight.c Taillight.h Brakelight_aliases.h Brakelight.c Brakelight.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: lab4_PSoC5lib (library)
