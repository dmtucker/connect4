# Keil uVision project part2_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: part2_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h ADC.c ADC.h ADC_PM.c ADC_INT.c Clock.c Clock.h Accelerator_aliases.h Accelerator.c Accelerator.h Tachometer_aliases.h Tachometer.c Tachometer.h PWM.c PWM.h PWM_PM.c Speed_aliases.h Speed.c Speed.h LCD.c LCD.h LCD_PM.c Counter.c Counter.h Counter_PM.c Timer.c Timer.h Timer_PM.c ADC_theACLK.c ADC_theACLK.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_AMux.c ADC_AMux.h LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Sample.c Sample.h Toggle_aliases.h Toggle.c Toggle.h Mode.c Mode.h Indicator_aliases.h Indicator.c Indicator.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: part2_PSoC5lib (library)
