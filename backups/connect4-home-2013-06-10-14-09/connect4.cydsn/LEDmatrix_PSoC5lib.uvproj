# Keil uVision project LEDmatrix_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: LEDmatrix_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Row.c Row.h Red.c Red.h Green.c Green.h Blue.c Blue.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h R1_aliases.h R1.c R1.h R5_aliases.h R5.c R5.h R2_aliases.h R2.c R2.h R3_aliases.h R3.c R3.h R4_aliases.h R4.c R4.h R6_aliases.h R6.c R6.h R7_aliases.h R7.c R7.h R8_aliases.h R8.c R8.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h C3_G_aliases.h C3_G.c C3_G.h C3_R_aliases.h C3_R.c C3_R.h C2_B_aliases.h C2_B.c C2_B.h C2_G_aliases.h C2_G.c C2_G.h C2_R_aliases.h C2_R.c C2_R.h C1_B_aliases.h C1_B.c C1_B.h C1_G_aliases.h C1_G.c C1_G.h C1_R_aliases.h C1_R.c C1_R.h C3_B_aliases.h C3_B.c C3_B.h C4_R_aliases.h C4_R.c C4_R.h C4_G_aliases.h C4_G.c C4_G.h C4_B_aliases.h C4_B.c C4_B.h C5_R_aliases.h C5_R.c C5_R.h C5_G_aliases.h C5_G.c C5_G.h C5_B_aliases.h C5_B.c C5_B.h C6_R_aliases.h C6_R.c C6_R.h C6_G_aliases.h C6_G.c C6_G.h C6_B_aliases.h C6_B.c C6_B.h C7_R_aliases.h C7_R.c C7_R.h C7_G_aliases.h C7_G.c C7_G.h C7_B_aliases.h C7_B.c C7_B.h C8_R_aliases.h C8_R.c C8_R.h C8_G_aliases.h C8_G.c C8_G.h C8_B_aliases.h C8_B.c C8_B.h CapSense.c CapSense.h CapSense_CSHL.c CapSense_CSHL.h CapSense_INT.c CapSense_Pins.c CapSense_Pins.h CapSense_PM.c CapSense_SMS_Wrapper.c CapSense_TunerHelper.c CapSense_TunerHelper.h CapSense_CompCH0.c CapSense_CompCH0.h CapSense_CompCH0_PM.c CapSense_IdacCH0.c CapSense_IdacCH0.h CapSense_IdacCH0_PM.c CapSense_AMuxCH0.c CapSense_AMuxCH0.h Timer.c Timer.h Timer_PM.c ISR.c ISR.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: LEDmatrix_PSoC5lib (library)
