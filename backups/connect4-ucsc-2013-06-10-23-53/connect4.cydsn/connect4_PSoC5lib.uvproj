# Keil uVision project connect4_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: connect4_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Row.c Row.h Red.c Red.h Green.c Green.h Blue.c Blue.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h CapSense.c CapSense.h CapSense_CSHL.c CapSense_CSHL.h CapSense_INT.c CapSense_Pins.c CapSense_Pins.h CapSense_PM.c CapSense_SMS_Wrapper.c CapSense_TunerHelper.c CapSense_TunerHelper.h CapSense_CompCH0.c CapSense_CompCH0.h CapSense_CompCH0_PM.c CapSense_IdacCH0.c CapSense_IdacCH0.h CapSense_IdacCH0_PM.c CapSense_AMuxCH0.c CapSense_AMuxCH0.h Timer.c Timer.h Timer_PM.c UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c UART_IntClock.c UART_IntClock.h Beam.c Beam.h RemoteLED_aliases.h RemoteLED.c RemoteLED.h Connector_aliases.h Connector.c Connector.h Location.c Location.h Row_aliases.h Red_aliases.h Green_aliases.h Blue_aliases.h Colors_aliases.h Colors.c Colors.h Update_aliases.h Update.c Update.h Shifter_aliases.h Shifter.c Shifter.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: connect4_PSoC5lib (library)
